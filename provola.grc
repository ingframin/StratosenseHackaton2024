options:
  parameters:
    author: fminucci
    generate_options: qt_gui
    id: provola
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: att
  id: variable_qtgui_dial_control
  parameters:
    maximum: '100'
    minimum: '0'
    showvalue: 'False'
    type: real
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: new_hier_0
  id: new_hier
  parameters:
    attenuation: att
    carrier_freq: '0'
    delay: '0'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', new_hier_0, '0']
- [new_hier_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
