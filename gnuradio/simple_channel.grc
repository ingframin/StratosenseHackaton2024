options:
  parameters:
    generate_options: hb
    id: simple_channel
    output_language: python
    title: Simple Channel Model
  states: {}

blocks:
- name: attenuation
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: carrier_freq
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: delay
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, center_frequency=0.0, attenuation=1.0, delay=0.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='simple channel',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.center_frequency=center_frequency
              self.attenuation = attenuation
              self.delay=delay

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.attenuation * np.exp(2*np.pi*self.delay*self.center_frequency*1.0j)
              return len(output_items[0])
    attenuation: attenuation
    center_frequency: carrier_freq
    delay: delay
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [epy_block_0, '0', pad_sink_0, '0']
- [pad_source_1, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
